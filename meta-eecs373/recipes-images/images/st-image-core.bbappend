CORE_IMAGE_EXTRA_INSTALL += "libopencv-core libopencv-imgproc libopencv-calib3d python3"
CORE_IMAGE_EXTRA_INSTALL += "ls-gl-ext"